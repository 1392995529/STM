# IAR project YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder.ewp, settings and files
configuration YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/F4xx/Inc; ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\Users\86150\Desktop\FHA11C工程\YSF4_HAL_MOTOR-658. FOC_v5.4.3_42PMSM_encoder\YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder\Drivers\STM32F4xx_HAL_Driver; H:\Postgraduate Project\Laser Tracing System\Laser Tracing Control System Ⅲ\Control\FHA11C\YSF4_HAL_MOTOR-658. FOC_v5.4.3_42PMSM_encoder\YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder\Src; H:\Postgraduate Project\Laser Tracing System\Laser Tracing Control System Ⅲ\Control\FHA11C\YSF4_HAL_MOTOR-658. FOC_v5.4.3_42PMSM_encoder\YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder.hex
  ILINK.IlinkOutputFile: YS-F4_FOC-021. FOC_v5.4.3_42PMSM_encoder.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: AD7606.c ADgpio.c ADspi.c ADtim.c bsp_CAN.c bsp_key.c Handwheel_encoder.c luenberge.c main.c Matrx.c mc_api.c mc_config.c mc_interface.c mc_math.c mc_parameters.c mc_position.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_mc_it.c ui_task.c user_interface.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_2_f4xx_pwm_curr_fdbk.c
